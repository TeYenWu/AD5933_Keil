# Keil uVision project AD5933.uvproj, settings and files
target M453 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: AD5933
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4=1
  c include: Library\Device\Nuvoton\M451Series\Include;Library\CMSIS\Include;Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Users
    ./: main.c AD5933.c AD5933.h myUart.c myUart.h
  group CMSIS
    ./Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
    ./Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
  group Library
    ./Library/StdDriver/src/: clk.c gpio.c i2c.c pdma.c retarget.c spi.c sys.c timer.c uart.c
    ./Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
